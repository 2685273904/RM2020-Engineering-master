# Keil uVision project RoboMaster.uvprojx, settings and files
target STM32F427VITx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoboMaster +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=12000000,USE_STDPERIPH_DRIVER,STM32F427_437xx,ARM_MATH_CM4,__CC_ARM,__FPU_USED =1,__FPU_PRESENT = 1
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\SEEGER\SystemView\Src\SEGGER;..\..\Libraries\SEEGER\SystemView\Src\Sample\FreeRTOSV10;..\..\Libraries\SEEGER\SystemView\Src\Config;..\..\Libraries\FreeRTOS\include;..\..\Libraries\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\BSP;..\..\Devices;..\..\Apps;..\..\Tasks;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Docs
    ../../: README.md
  group User
    ../../User/: stm32f4xx_it.c main.c stm32f4xx_conf.h UserMath.c userCode.c user_common.h typedefs.h FreeRTOSConfig.h
  group Tasks
    ../../Tasks/: SystemInit_Tasks.c UpperStructure_Task.c Command_Task.c Chassis_Task.c DevicesMonitor_Tasks.c CanMsg_Task.c PlayRoom_Task.c
  group Apps
    ../../Apps/: PID.c Filter.c Ramp.c BulletCatcher_control.c Chassis_control.c Lifting_control.c UpperStructure.c Cloud_control.c DevicesMonitor.c Robot_control.c Mutually_control.c Magazine_control.c
    ../../Devices/: GY_IMU.c
  group Devices
    ../../Devices/: LED.c key.c M3508_Motor.c M6623_Motor.c DR16_Receiver.c MC01_JudgeSystem.c Laser.c GAS_8.c Buzzer.c Hall_IO.c DynamixelServo.c ANO.c
  group BSP
    ../../BSP/: CAN.c USART.c TIM.c I2C_SW.c SPI_HW.c NVIC.c delay.c
  group FreeRTOS/portable
    ../../Libraries/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/sources
    ../../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Libraries/DSP
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Libraries/StdPeriph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SEEGER/SystemView
    ../../Libraries/SEEGER/SystemView/Src/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../../Libraries/SEEGER/SystemView/Src/Sample/FreeRTOSV10/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../../Libraries/SEEGER/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group SEEGER/RTT
    ../../Libraries/SEEGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group startup
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s startup_stm32f427_437xx.s
    ../../User/: system_stm32f4xx.c
